<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/temperatureNotify_LP_EM_CC2745R10_FPGA_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>