<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/gpiointerrupt_LP_CC2340R2_FPGA_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>