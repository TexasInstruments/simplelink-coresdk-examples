<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/ecdsaSignVerify_LP_EM_CC2755P10_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>