<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/aesctr_LP_EM_CC2755R10_BG_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>