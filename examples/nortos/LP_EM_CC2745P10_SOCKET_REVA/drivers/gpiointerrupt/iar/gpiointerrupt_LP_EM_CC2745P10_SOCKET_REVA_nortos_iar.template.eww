<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/gpiointerrupt_LP_EM_CC2745P10_SOCKET_REVA_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>