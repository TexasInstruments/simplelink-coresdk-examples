<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/i2ctarget_LP_EM_CC2755R10_BG_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>