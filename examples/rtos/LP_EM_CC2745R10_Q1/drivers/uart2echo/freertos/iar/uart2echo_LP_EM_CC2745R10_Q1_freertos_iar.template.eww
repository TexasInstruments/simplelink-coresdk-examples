<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/uart2echo_LP_EM_CC2745R10_Q1_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>