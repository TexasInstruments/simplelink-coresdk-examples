# IAR project temperatureNotify_LP_EM_CC2745R10_SOCKET_REVA_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: temperatureNotify_LP_EM_CC2745R10_SOCKET_REVA_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
