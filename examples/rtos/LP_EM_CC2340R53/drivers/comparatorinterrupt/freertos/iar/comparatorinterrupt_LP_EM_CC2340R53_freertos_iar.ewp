# IAR project comparatorinterrupt_LP_EM_CC2340R53_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: comparatorinterrupt_LP_EM_CC2340R53_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
